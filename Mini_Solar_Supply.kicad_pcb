# Repository jvarghes2501/Solar_power_supply

File README.md:

# Tiny Solar Supply – Regulated 3.3V Solar Boost Converter (Custom PCB)

This project is a custom PCB implementation of the **Tiny Solar Supply** boost converter originally designed by **Clemens Valens (Elektor)**. The circuit takes a **1.2 V Ni-MH AA battery**, charged by a small solar panel, and boosts it to a stable **3.3 V output** suitable for microcontrollers and other low-power electronics.

My contribution in this repository is the **full PCB design**, recreated based on the schematic published by Elektor.
Original article:
**Elektor Magazine – “Tiny Solar Supply: Sunlight In, 3.3 V Out”**
[https://www.elektormagazine.com/magazine/elektor-305/62009](https://www.elektormagazine.com/magazine/elektor-305/62009)
*All credit for the original circuit concept and schematic goes to Elektor and the author, Clemens Valens.*

---

## 📸 PCB 3D Renders

### Front-Side 3D View

### Top-Down 3D View

---

## 🔧 Overview

This PCB implements a **step-up DC/DC converter** using the AP3015/AP3015A.
The goal is to repurpose small garden-light solar panels and their rechargeable batteries into a reliable 3.3 V supply with **automatic day/night switching**.

### Key Features

* Boosts **1.0–1.2 V** battery voltage to a regulated **3.3 V** output
* **Solar charging path** using SS14 diodes
* Automatic shutdown of the boost converter when the solar panel is illuminated
* Optional **ON/OFF jumper** (J3)
* Compact PCB designed to fit inside typical solar-light enclosures
* Designed using KiCad

---

## 🛠️ Circuit Details

The heart of the circuit is the **AP3015** step-up converter.
Output voltage is set by the ratio of R1/R2:

```
Vout = 1.23 × (1 + R1/R2)
```

A 2N7002 MOSFET controls automatic shutdown:

* When the solar panel produces voltage, it **charges the battery** and **disables the boost converter**
* When sunlight fades, the boost converter turns on automatically and powers the load

---
## 🏷️ Credits

Original circuit and documentation by:
**Clemens Valens – Elektor Labs**
Published in Elektor Magazine (Circuit Special 2023)

This repository only contains **my PCB recreation** of that design.

---

## 📜 License & Usage Notes

Please respect Elektor’s original licensing terms for the circuit and article.
This PCB design is shared for educational and personal use.

---

## KiCad design Mini_Solar_Supply.kicad_pcb

Parts:
C1: 4.7uF, 50V, X7R(0805); C_0805_2012Metric
C2: 22uF, 10V, X7R(1206); C_1206_3216Metric
C3: 10uF, 50V, X7R(0805); C_0805_2012Metric
D1, D2: SS14; DIOM4325X250N; PARTREV O2102
J1, J2, J3: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Horizontal
L1: ASPI-0630LR-100M-T15; IND_ASPI-0630LR_ABR
Q1: 2N7002; SOT-23-3; MPN 2N7002; Digi-Key_PN 2N7002NCT-ND
R1, R4: 1 MOhm; R_0805_2012Metric
R2: 604 kOhm, 1%; R_0805_2012Metric
R3: 10 kOhm; R_0805_2012Metric
U1: AP3015AKTR-G1; SOT23-5_1P55X2P9_DIO

Connections:
/BAT_P: D2.C, J2.1, J3.2
/OUT_P: C2.1, C3.1, D1.C, J1.2, R1.1
/Solar_P+: D2.A, J4.1, Q1.1 (G), R4.1
GNDD: C1.2, C2.2, J1.1, J2.2, J4.2, Q1.2 (S), R2.2, R4.2, U1.2 (GND)
unnamed: C1.1, J3.1, L1.2, R3.1, U1.5 (VIN)
unnamed: Q1.3 (D), R3.2, U1.4 (SHDN)
unnamed: C3.2, R1.2, R2.1, U1.3 (FB)
unnamed: D1.A, L1.1, U1.1 (SW)

Board: 2 copper layers, 39.2 x 20.8 mm, 16 parts (0 on the bottom side), 8 nets.

## Commit log

2025-12-10 Added the parts to schematic and associated there footprints
2025-12-10 changed the AP3015AKTR-G1 to alighn the pins and connected all the components in the schematic circuit
2025-12-11 fixed errors and performed CRC check
2025-12-11 Completed routing and verified using CRC
2025-12-11 Created gerber and drill hole files for manufacturing
2025-12-11 Added 3d rendered images of the design
2025-12-11 Add README for Tiny Solar Supply project
    This README provides an overview of the Tiny Solar Supply project, including details about the PCB design, features, circuit details, and credits.
